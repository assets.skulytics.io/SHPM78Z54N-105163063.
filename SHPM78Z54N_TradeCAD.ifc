Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: SHPM78Z54N_TradeCAD.ifc
Time: 2023-01-25T20:29:39
Author: jsink
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy
SHPM78Z54N_TradeCAD.dxf - ObjectType: SketchupComponentInstance
